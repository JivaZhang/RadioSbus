# IAR project RadioSbus.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205VG ST STM32F205VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F205xx
  ICCARM.PreInclude: D:\efly\workspace\RadioSbusEDcoder\RadioSbus\stm32_lib\STM32Cube_FW_F2_V1.4.0\Drivers\CMSIS\Device\ST\STM32F2xx\Include\stm32f2xx.h
  ICCARM.CCIncludePath2: ..\stm32_lib\STM32Cube_FW_F2_V1.4.0\Drivers\CMSIS\Include; ..\stm32_lib\STM32Cube_FW_F2_V1.4.0\Drivers\CMSIS\Device\ST\STM32F2xx\Include; ..\Application\inc; $TOOLKIT_DIR$\src\flashloader\ST\FlashSTM32F2xx\inc; ..\..\STM32Cube_FW_F2_V1.4.0\Drivers\STM32F2xx_HAL_Driver\Inc; ..\stm32_lib\STM32Cube_FW_F2_V1.4.0\Middlewares\Third_Party\FreeRTOS\Source\include; ..\stm32_lib\STM32Cube_FW_F2_V1.4.0\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\stm32_lib\STM32Cube_FW_F2_V1.4.0\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\modulation\mavlink\include; ..\mlib\TraceRecorder\config; ..\mlib\TraceRecorder\streamports\ARM_ITM\include; ..\mlib\TraceRecorder\include; ..\stm32_lib\STM32Cube_FW_F2_V1.4.0\Drivers\CMSIS\Device\ST\STM32F2xx\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: STM32F205xx
  AARM.AUserIncludes: ..\stm32_lib\STM32Cube_FW_F2_V1.4.0\Drivers\CMSIS\Device\ST\STM32F2xx\Include; ..\stm32_lib\STM32Cube_FW_F2_V1.4.0\Drivers\STM32F2xx_HAL_Driver\Inc; ..\mlib\TraceRecorder\config; ..\mlib\TraceRecorder\streamports\ARM_ITM\include; ..\mlib\TraceRecorder\include; ..\Application\inc
  OBJCOPY.OOCOutputFile: RadioSbus.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f205xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../Application/src/: main.c
  group Application/UserHal
    ../Application/src/: freertos.c gpio.c radio.c sbus.c usart.c userhardwareinit.c watchdog.c
  group Hal/CMSIS
    ../stm32_lib/STM32Cube_FW_F2_V1.4.0/Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f205xx.s
    ../stm32_lib/STM32Cube_FW_F2_V1.4.0/Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Hal/STM32F2xx_HAL_Driver
    ../stm32_lib/STM32Cube_FW_F2_V1.4.0/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_can.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_cryp.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_dcmi.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hash.c stm32f2xx_hal_hcd.c stm32f2xx_hal_i2c.c stm32f2xx_hal_i2s.c stm32f2xx_hal_irda.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_msp_template.c stm32f2xx_hal_nand.c stm32f2xx_hal_nor.c stm32f2xx_hal_pccard.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_smartcard.c stm32f2xx_hal_spi.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_timebase_rtc_alarm_template.c stm32f2xx_hal_timebase_rtc_wakeup_template.c stm32f2xx_hal_timebase_tim_template.c stm32f2xx_hal_uart.c stm32f2xx_hal_usart.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_sdmmc.c stm32f2xx_ll_usb.c
  group Library/tracelyzer
    ../mlib/TraceRecorder/: trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c
    ../mlib/TraceRecorder/streamports/ARM_ITM/: trcStreamingPort.c
  group Modulation/FreeRTOS
    ../stm32_lib/STM32Cube_FW_F2_V1.4.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../stm32_lib/STM32Cube_FW_F2_V1.4.0/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../stm32_lib/STM32Cube_FW_F2_V1.4.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../stm32_lib/STM32Cube_FW_F2_V1.4.0/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Modulation/mavlink
    ../modulation/mavlink/include/: checksum.h common.h mavlink.h mavlink_conversions.h mavlink_helpers.h mavlink_types.h protocol.h version.h
  group Modulation/mavlink/common
    ../modulation/mavlink/include/common/: common.h mavlink.h
